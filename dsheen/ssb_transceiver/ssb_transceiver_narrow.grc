options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: RF_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Frequency
    orient: Qt.Horizontal
    start: 1280e6
    step: '10'
    stop: 1300e6
    value: 1296.100e6
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: average_samples_1
  id: variable
  parameters:
    value: int(integration_time*samp_rate/float(num_pts*int(0.05*samp_rate/float(num_pts))))
  states: {}
- name: dec_rate_1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dec_rate_2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: MIC GAIN
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: num_pts
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: ptt_allowed
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ptt_command
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0,1,1
    label: PTT
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RX GAIN
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*dec_rate_1*dec_rate_2*16/3
  states: {}
- name: sdr_center_freq
  id: variable
  parameters:
    value: 1295.800e6
  states: {state: disabled}
- name: sdr_gain
  id: variable
  parameters:
    value: '[rx_gain, 0]'
  states: {}
- name: sdr_tx_gain
  id: variable
  parameters:
    value: '[40, tx_gain]'
  states: {}
- name: spectrum_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Spectrum Bandwidth
    orient: Qt.Horizontal
    start: 5e3
    step: 1e3
    stop: samp_rate*0.99
    value: 50e3
  states: {state: disabled}
- name: spectrum_bandwidth
  id: variable
  parameters:
    value: 20e3
  states: {state: disabled}
- name: spectrum_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: SPECTRUM MAX
    orient: Qt.Horizontal
    rangeType: int
    start: '-90'
    step: '5'
    stop: '-10'
    value: '-60'
  states: {}
- name: spectrum_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: SPECTRUM MIN
    orient: Qt.Vertical
    rangeType: int
    start: '-140'
    step: '5'
    stop: '-60'
    value: '-110'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,1
    label: TX PWR
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: RX VOLUME
    orient: Qt.Horizontal
    start: '-1'
    step: '.1'
    stop: '2'
    value: '0'
  states: {}
- name: audio_mag_sqrd
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.0001'
    threshold: '0'
    type: c
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1.97'
    high_cutoff_freq: 2.7e3
    interp: 256/48
    low_cutoff_freq: '100'
    samp_rate: 48e3
    type: fir_filter_fcc
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1.97'
    high_cutoff_freq: 2.7e3
    low_cutoff_freq: '100'
    samp_rate: audio_samp_rate
    type: fir_filter_ccc
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**volume
    maxoutbuf: '64'
    minoutbuf: '8'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '[0,1][ptt_allowed]'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 10e6
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: 3e3
    digital_bandw_ch1: '0'
    gain_dB_ch0: sdr_tx_gain[ptt_allowed]
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch0: '1'
    pa_path_ch1: '1'
    rf_freq: RF_frequency
    samp_rate: samp_rate
    serial: 0009060B00471B22
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: samp_rate
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: samp_rate
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: samp_rate*0.99
    digital_bandw_ch1: '0'
    gain_dB_ch0: sdr_gain[ptt_allowed]
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    maxoutbuf: '2048'
    minoutbuf: '512'
    oversample: '0'
    rf_freq: RF_frequency
    samp_rate: samp_rate
    serial: 0009060B00471B22
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '8'
    gain: '1.97'
    samp_rate: samp_rate/(dec_rate_1*dec_rate_2)
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 400e3
    decim: dec_rate_1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: dec_rate_2
    gain: '1.97'
    samp_rate: samp_rate/dec_rate_1
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: RF_frequency-1e3
    fftsize: '1024'
    gui_hint: 2,0,1,3
    label: RX SIGNAL POWER
    name: '"RX SPECTRUM"'
    showports: 'True'
    type: complex
    update_time: '.1'
    wintype: firdes.WIN_BLACKMAN
    ymax: spectrum_max
    ymin: spectrum_min
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 256e3/8
    fc: RF_frequency
    fftsize: '1024'
    gui_hint: 2,3,1,2
    label: RX SIGNAL POWER
    name: '"RX TUNING SPECTRUM"'
    showports: 'True'
    type: complex
    update_time: '.1'
    wintype: firdes.WIN_BLACKMAN
    ymax: spectrum_max-9
    ymin: spectrum_min-9
  states: {}
- name: qtgui_freq_sink_x_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 48e3
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 4,2,2,1
    label: BASEBAND SIGNAL POWER
    name: '"BASEBAND TX"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0,2,2
    label1: ''
    name: '"MICROPHONE INPUT"'
    size: '4096'
    srate: 48e3
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,3,2,2
    label1: ''
    label2: ''
    name: '"RF BASEBAND WAVEFORM"'
    size: '32768'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: RF_frequency
    fftsize: '1024'
    gui_hint: 3,0,1,3
    int_max: spectrum_max
    int_min: spectrum_min
    name: '"RX SPECTRUM"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 256e3/8
    fc: RF_frequency
    fftsize: '1024'
    gui_hint: 3,3,1,2
    int_max: spectrum_max-10
    int_min: spectrum_min-10
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '16'
    maxoutbuf: '4096'
    minoutbuf: '1024'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '3'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_2, '0']
- [band_pass_filter_0_0, '0', audio_mag_sqrd, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_freq_sink_x_1_1_0, '0']
- [blocks_multiply_const_vxx_2, '0', rational_resampler_xxx_0, '0']
- [limesdr_source_0, '0', low_pass_filter_2, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_2, '0', low_pass_filter_2_0, '0']
- [low_pass_filter_2_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_2_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_1, '0', band_pass_filter_0_0, '0']
- [rational_resampler_xxx_2, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
