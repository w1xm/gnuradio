options:
  parameters:
    generate_options: no_gui
    id: flowgraph
    output_language: python
  states: {}

blocks:
- name: gain_correction_lin
  id: variable
  parameters:
    value: 1/(rf_path_gain_correction_linear*sdr_gain_lin*sdr_power_offset)
  states: {}
- name: if_bandwidth_0
  id: variable
  parameters:
    value: 2*output_vector_bandwidth+4.5e6
  states: {}
- name: if_bandwidth_1
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: if_filter_decimation_rate
  id: variable
  parameters:
    value: int(samp_rate/(1.1*if_bandwidth_1))
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/if_filter_decimation_rate
  states: {}
- name: integration_bandwidth
  id: variable
  parameters:
    value: output_vector_bandwidth/num_channels
  states: {}
- name: integration_dec_rate
  id: variable
  parameters:
    value: int(integration_time*if_samp_rate/num_channels)
  states: {}
- name: integration_scale_factor
  id: variable
  parameters:
    value: np.full((num_channels),float(1.0/(integration_dec_rate*integration_bandwidth)),dtype=float)
  states: {}
- name: lna_gain_measured
  id: variable
  parameters:
    value: '33.33'
  states: {state: disabled}
- name: num_channels
  id: variable
  parameters:
    value: '512'
  states: {}
- name: offset_frequency
  id: variable
  parameters:
    value: output_vector_bandwidth/2+1e5
  states: {}
- name: output_vector_bandwidth
  id: variable
  parameters:
    value: samp_rate/if_filter_decimation_rate
  states: {}
- name: rf_path_gain_correction_linear
  id: variable
  parameters:
    value: '211.67'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16777216'
  states: {}
- name: sdr_frequency
  id: parameter
  parameters:
    value: 1420.406e6
  states: {}
- name: sdr_gain
  id: parameter
  parameters:
    value: '40'
  states: {}
- name: sdr_gain_lin
  id: variable
  parameters:
    value: 10**(sdr_gain/20)
  states: {}
- name: sdr_power_offset
  id: variable
  parameters:
    value: np.sqrt(50)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integration_dec_rate
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: integration_scale_factor
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain_correction_lin
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_channels
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_channels)
  states: {}
- name: file_sink_path
  id: parameter
  parameters:
    value: '''/tmp/out'''
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset_frequency
    decim: if_filter_decimation_rate
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,output_vector_bandwidth/2.05,output_vector_bandwidth/10,firdes.WIN_BLACKMAN_HARRIS)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integration_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_channels=512):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32, num_channels)],
                  out_sig=[]
              )
              self.num_channels = num_channels
              self.integration = None
              self.integration_count = 0
              self.integration_remaining = -1

          def work(self, input_items, output_items):
              count = len(input_items[0])
              if self.integration_remaining > 0:
                  if self.integration is None:
                      # Throw away old vectors
                      self.integration = np.zeros(self.num_channels, dtype=float)
                      return count
                  for vec in input_items[0]:
                      self.integration += vec
                      self.integration_remaining -= 1
                      if not self.integration_remaining:
                          return count
              return count

          def integrate(self, count):
              self.integration = None
              self.integration_count = count
              self.integration_remaining = count

          def integrate_results(self):
              if self.integration_remaining:
                  return None
              return self.integration / self.integration_count
    num_channels: num_channels
  states: {}
- name: integration_time
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: limesdr_source_2
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: if_bandwidth_0
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 15e6
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: if_bandwidth_0
    digital_bandw_ch1: '0'
    gain_dB_ch0: sdr_gain
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: sdr_frequency-offset_frequency
    samp_rate: samp_rate
    serial: 0009060B00471B22
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', integration_block, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_multiply_const_xx_0, '0']
- [limesdr_source_2, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
