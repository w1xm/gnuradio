options:
  parameters:
    generate_options: no_gui
    id: flowgraph
    output_language: python
  states: {}

blocks:
- name: antenna_gain_estimated
  id: variable
  parameters:
    value: '173'
  states: {}
- name: cable_loss
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: channel_map
  id: variable
  parameters:
    value: range(int(num_channels/2.0+1.0),num_channels,1)+range(0,int(num_channels/2.0+1.0),1)
  states: {}
- name: channel_skirt
  id: variable
  parameters:
    value: integration_bandwidth/100
  states: {}
- name: if_bandwidth_0
  id: variable
  parameters:
    value: 5.5e6
  states: {}
- name: if_bandwidth_1
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: if_filter_decimation_rate
  id: variable
  parameters:
    value: int(samp_rate/(1.1*if_bandwidth_1))
  states: {}
- name: if_filter_gain
  id: variable
  parameters:
    value: 1/(lna_gain_measured*cable_loss*sdr_gain_lin*sdr_power_offset)
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/if_filter_decimation_rate
  states: {}
- name: integration_bandwidth
  id: parameter
  parameters:
    value: 5e3
  states: {}
- name: integration_dec_rate
  id: variable
  parameters:
    value: int(integration_time*if_samp_rate/num_channels)
  states: {}
- name: integration_scale_factor
  id: variable
  parameters:
    value: np.full((num_channels),float(1.0/(integration_time*integration_bandwidth*50)),dtype=float)
  states: {}
- name: lna_gain_measured
  id: variable
  parameters:
    value: '33.33'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: int((samp_rate/if_filter_decimation_rate)/integration_bandwidth)
  states: {}
- name: offset_frequency
  id: variable
  parameters:
    value: if_bandwidth_1/2+1e5
  states: {}
- name: output_vector_bandwidth
  id: variable
  parameters:
    value: samp_rate/if_filter_decimation_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: sdr_frequency
  id: parameter
  parameters:
    value: 1420.406e6
  states: {}
- name: sdr_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sdr_gain_lin
  id: variable
  parameters:
    value: 10**(sdr_gain/20)
  states: {}
- name: sdr_power_offset
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset_frequency'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_channels
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_sink_path
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integration_dec_rate
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: integration_scale_factor
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: num_channels
    type: complex
  states: {bus_sink: true}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_channels
    type: float
  states: {state: disabled}
- name: file_sink_path
  id: parameter
  parameters:
    value: '''/tmp/out'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integration_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_channels=500):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32, num_channels)],
                  out_sig=[]
              )
              self.num_channels = num_channels
              self.integration = None
              self.integration_count = 0
              self.integration_remaining = -1

          def work(self, input_items, output_items):
              count = len(input_items[0])
              if self.integration_remaining > 0:
                  if self.integration is None:
                      # Throw away old vectors
                      self.integration = np.zeros(self.num_channels, dtype=float)
                      return count
                  for vec in input_items[0]:
                      self.integration += vec
                      self.integration_remaining -= 1
                      if not self.integration_remaining:
                          return count
              return count

          def integrate(self, count):
              self.integration = None
              self.integration_count = count
              self.integration_remaining = count

          def integrate_results(self):
              if self.integration_remaining:
                  return None
              return self.integration / self.integration_count
    num_channels: num_channels
  states: {}
- name: integration_time
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: limesdr_source_2
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: if_bandwidth_0
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 15e6
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: if_bandwidth_0
    digital_bandw_ch1: '0'
    gain_dB_ch0: sdr_gain
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: sdr_frequency-offset_frequency
    samp_rate: samp_rate
    serial: 0009060B00471B22
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: if_bandwidth_1/2
    decim: if_filter_decimation_rate
    gain: if_filter_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e5
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '0'
    bus_conns: '[channel_map,]'
    ch_map: channel_map
    nchans: num_channels
    osr: '1.0'
    taps: firdes.low_pass(1, if_samp_rate, (integration_bandwidth/2-channel_skirt), channel_skirt, firdes.WIN_HAMMING)
  states: {bus_source: true}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: num_channels
    srate: num_channels/integration_time
    type: float
    update_time: integration_time
    ymax: '100'
    ymin: '0'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_copy_0, '0', blocks_multiply_xx_1, '0']
- [blocks_copy_0_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', integration_block, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_1, '0']
- [blocks_streams_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [limesdr_source_2, '0', blocks_copy_0, '0']
- [limesdr_source_2, '0', blocks_copy_0_0, '0']
- [low_pass_filter_1, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '500', blocks_streams_to_vector_0, '500']

metadata:
  file_format: 1
